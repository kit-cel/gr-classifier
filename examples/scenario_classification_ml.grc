<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>scenario_classification_ml</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SNR_ch_1</value></param>
<param><key>block_id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>function_name</key><value>get_SNR_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SNR_ch_2</value></param>
<param><key>block_id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>function_name</key><value>get_SNR_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SNR_ch_3</value></param>
<param><key>block_id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>function_name</key><value>get_SNR_3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>SNR_ch_4</value></param>
<param><key>block_id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>function_name</key><value>get_SNR_4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>subchan_map</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fine_frequency_correction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Fine frequency correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchan</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nguard_bins</value></param>
<param><key>comment</key><value>per side of the band</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>256 * 8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>poll_rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pu_frame_len</value></param>
<param><key>value</key><value>80*5*9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>label</key><value>RX gain (normalized)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1e7)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len</value></param>
<param><key>comment</key><value>at 10 MS/s</value></param>
<param><key>value</key><value>(su_frame_len_low_rate + len(taps))* 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>su_frame_len_low_rate</value></param>
<param><key>comment</key><value>calculated for 256 byte payload</value></param>
<param><key>value</key><value>sync.get_frame_samps(True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*6, [1,]*116, [0,]*6))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0 </value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()-1</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))</value></param>
<param><key>bands</key><value>nchan</value></param>
<param><key>guard</key><value>nguard_bins</value></param>
<param><key>bits</key><value>packetlen_base</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 12) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>np.array([0.003524782368913293, 0.002520402194932103, -3.532667373554307e-17, -0.0025783423334360123, -0.0036887258756905794, -0.0026390093844383955, -3.7046301165340785e-18, 0.0027025998570024967, 0.003868663916364312, 0.0027693307492882013, -9.712380039780164e-18, -0.0028394402470439672, -0.004067056812345982, -0.0029131921473890543, 2.454170927498071e-17, 0.0029908770229667425, 0.004286897834390402, 0.0030728192068636417, -9.712380039780164e-18, -0.0031593774911016226, -0.004531863145530224, -0.0032509532757103443, -6.861573196148834e-18, 0.0033479968551546335, 0.004806521814316511, 0.003451012307778001, -9.712380039780164e-18, -0.0035605679731816053, -0.005116619635373354, -0.0036773078609257936, 2.849619674016194e-17, 0.003801962360739708, 0.005469490308314562, 0.003935364540666342, -9.712380039780164e-18, -0.004078468773514032, -0.0058746375143527985, -0.004232373554259539, -1.196125168755972e-17, 0.004398348741233349, 0.006344608962535858, 0.004577873274683952, -9.712380039780164e-18, -0.004772676154971123, -0.0068963137455284595, -0.004984795115888119, 3.532667373554307e-17, 0.005216646008193493, 0.00755310570821166, 0.005471116863191128, -9.712380039780164e-18, -0.0057516866363584995, -0.00834816973656416, -0.00606258912011981, 9.712380039780164e-18, 0.006409022491425276, 0.009330307133495808, 0.006797448266297579, -9.712380039780164e-18, -0.007235993165522814, -0.010574348270893097, -0.007735027000308037, 9.712380039780164e-18, 0.008307991549372673, 0.012201170437037945, 0.008972631767392159, -9.712380039780164e-18, -0.00975286029279232, -0.014419564977288246, -0.010681704618036747, 9.712380039780164e-18, 0.011806094087660313, 0.017623912543058395, 0.013195047155022621, -9.712380039780164e-18, -0.01495438627898693, -0.022659316658973694, -0.017255060374736786, 9.712380039780164e-18, 0.020392345264554024, 0.03172304481267929, 0.02492397651076317, -9.712380039780164e-18, -0.03204511106014252, -0.052871737629175186, -0.04486315697431564, 9.712380039780164e-18, 0.0747719332575798, 0.15861520171165466, 0.22431577742099762, 0.24915219843387604, 0.22431577742099762, 0.15861520171165466, 0.0747719332575798, 9.712380039780164e-18, -0.04486315697431564, -0.052871737629175186, -0.03204511106014252, -9.712380039780164e-18, 0.02492397651076317, 0.03172304481267929, 0.020392345264554024, 9.712380039780164e-18, -0.017255060374736786, -0.022659316658973694, -0.01495438627898693, -9.712380039780164e-18, 0.013195047155022621, 0.017623912543058395, 0.011806094087660313, 9.712380039780164e-18, -0.010681704618036747, -0.014419564977288246, -0.00975286029279232, -9.712380039780164e-18, 0.008972631767392159, 0.012201170437037945, 0.008307991549372673, 9.712380039780164e-18, -0.007735027000308037, -0.010574348270893097, -0.007235993165522814, -9.712380039780164e-18, 0.006797448266297579, 0.009330307133495808, 0.006409022491425276, 9.712380039780164e-18, -0.00606258912011981, -0.00834816973656416, -0.0057516866363584995, -9.712380039780164e-18, 0.005471116863191128, 0.00755310570821166, 0.005216646008193493, 3.532667373554307e-17, -0.004984795115888119, -0.0068963137455284595, -0.004772676154971123, -9.712380039780164e-18, 0.004577873274683952, 0.006344608962535858, 0.004398348741233349, -1.196125168755972e-17, -0.004232373554259539, -0.0058746375143527985, -0.004078468773514032, -9.712380039780164e-18, 0.003935364540666342, 0.005469490308314562, 0.003801962360739708, 2.849619674016194e-17, -0.0036773078609257936, -0.005116619635373354, -0.0035605679731816053, -9.712380039780164e-18, 0.003451012307778001, 0.004806521814316511, 0.0033479968551546335, -6.861573196148834e-18, -0.0032509532757103443, -0.004531863145530224, -0.0031593774911016226, -9.712380039780164e-18, 0.0030728192068636417, 0.004286897834390402, 0.0029908770229667425, 2.454170927498071e-17, -0.0029131921473890543, -0.004067056812345982, -0.0028394402470439672, -9.712380039780164e-18, 0.0027693307492882013, 0.003868663916364312, 0.0027025998570024967, -3.7046301165340785e-18, -0.0026390093844383955, -0.0036887258756905794, -0.0025783423334360123, -3.532667373554307e-17, 0.002520402194932103])*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold_delta</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_3</value></param>
<param><key>value</key><value>SNR_ch_1</value></param>
<param><key>gui_hint</key><value>tab@0:</value></param>
<param><key>label</key><value>SNR CH 1 [dB]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_3_0</value></param>
<param><key>value</key><value>SNR_ch_2</value></param>
<param><key>gui_hint</key><value>tab@0:</value></param>
<param><key>label</key><value>SNR CH 2 [dB]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_3_1</value></param>
<param><key>value</key><value>SNR_ch_3</value></param>
<param><key>gui_hint</key><value>tab@0:</value></param>
<param><key>label</key><value>SNR CH 3 [dB]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_3_2</value></param>
<param><key>value</key><value>SNR_ch_4</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>SNR CH 4 [dB]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>64</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nfft</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>classifier_dl_class</key>
<param><key>id</key><value>classifier_dl_class_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/keras/checkpoint/new_adadelta_model_checkpoint.h5</value></param>
</block>
<block>
<key>classifier_dl_class</key>
<param><key>id</key><value>classifier_dl_class_0_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/keras/checkpoint/adamax_ckpt.h5</value></param>
</block>
<block>
<key>classifier_dl_class</key>
<param><key>id</key><value>classifier_dl_class_0_0_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/keras/checkpoint/sgd_model_checkpoint.h5</value></param>
</block>
<block>
<key>classifier_energy_detection_vcf</key>
<param><key>id</key><value>classifier_energy_detection_vcf_0</value></param>
<param><key>buff_size</key><value>256</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>threshold_delta_db</key><value>7</value></param>
</block>
<block>
<key>classifier_feature_extraction_f</key>
<param><key>id</key><value>classifier_feature_extraction_f_0</value></param>
<param><key>frame_len</key><value>pu_frame_len / nfft</value></param>
<param><key>nframes</key><value>50</value></param>
<param><key>sample_rate</key><value>samp_rate / nfft</value></param>
<param><key>stepsize</key><value>5</value></param>
</block>
<block>
<key>classifier_frame_detection_f</key>
<param><key>id</key><value>classifier_frame_detection_f_0</value></param>
<param><key>lookahead</key><value>5</value></param>
<param><key>su_frame_len</key><value>su_frame_len/nfft - 9</value></param>
<param><key>tolerance</key><value>5</value></param>
</block>
<block>
<key>classifier_ml_scn_classification_f</key>
<param><key>id</key><value>classifier_ml_scn_classification_f_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/sklearn/joblib/dtc_full_data_set_depth_50.pkl</value></param>
<param><key>scaled</key><value>False</value></param>
<param><key>scalerfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/weights/scaler_saved.pkl</value></param>
</block>
<block>
<key>classifier_ml_scn_classification_f</key>
<param><key>id</key><value>classifier_ml_scn_classification_f_0_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/sklearn/joblib/knn_full_data_set_4_neighbors.pkl</value></param>
<param><key>scaled</key><value>False</value></param>
<param><key>scalerfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/weights/scaler_saved.pkl</value></param>
</block>
<block>
<key>classifier_ml_scn_classification_f</key>
<param><key>id</key><value>classifier_ml_scn_classification_f_0_0_0</value></param>
<param><key>modelfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/sklearn/joblib/svc_full_data_set_rbf_1e6.pkl</value></param>
<param><key>scaled</key><value>True</value></param>
<param><key>scalerfile</key><value>/home/cuervo/thesis/cognitive_radio_ml/trained_models/sklearn/joblib/scaler_saved.pkl</value></param>
</block>
<block>
<key>classifier_vector_average_vcvc</key>
<param><key>id</key><value>classifier_vector_average_vcvc_0</value></param>
<param><key>n_samples</key><value>120</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nfft)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(64)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab@1: 1, 0, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Decision Tree"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab@1:1, 1, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Knearest"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@1:1, 2, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"SVM"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@2:1, 2, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"SVM"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_1</value></param>
<param><key>gui_hint</key><value>tab@2:1, 1, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Knearest"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>tab@1:0, 0, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>Adadelta</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0</value></param>
<param><key>gui_hint</key><value>tab@1:0, 1, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Adamax"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0_0</value></param>
<param><key>gui_hint</key><value>tab@1:0, 2, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"SGD"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@2:0, 2, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"SGD"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@2:2, 0, 1, 3</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"previous implementation"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0_1</value></param>
<param><key>gui_hint</key><value>tab@2:0, 1, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Adamax"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_1</value></param>
<param><key>gui_hint</key><value>tab@2:0, 0, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>Adadelta</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_2</value></param>
<param><key>gui_hint</key><value>tab@2: 1, 0, 1, 1</value></param>
<param><key>color1</key><value>5</value></param>
<param><key>name</key><value>"Decision Tree"</value></param>
<param><key>ncols</key><value>10</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tab@0:</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Averaged power per subchannel"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>5000</value></param>
<param><key>srate</key><value>samp_rate // nfft</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>scenario_classification_f</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import scipy.stats as st
from gnuradio import gr
import pmt


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Classify scenarios"""

    def __init__(self, tconst=2, tau1=5, tau2=10, lambda1=20, lambda2=50, lambda3=100):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Scenario classification',   # will show up in GRC
            in_sig=[np.float32]*6,
            out_sig=[(np.float32, 10)]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.tconst = tconst
        self.tau1 = tau1
        self.tau2 = tau2
        self.lambda1 = lambda1
        self.lambda2 = lambda2
        self.lambda3 = lambda3
        self.nchan = 4
        self.scenario_tau = np.array([self.tau1, self.tau2, 2*self.tau1, 4*self.tau2, self.tau1, self.tau1, self.tconst, self.lambda1, self.lambda2, self.lambda3, 0])  # scenario 10 is "unsure, don't send"
        self.scenario_send_window = self.scenario_tau.copy()  # the send window for the hopping and Poisson scenarios differs from the deterministic ones
        self.scenario_send_window[2] = self.tau1
        self.scenario_send_window[3] = self.tau2
        for i in range(7, 10):
          self.scenario_send_window[i] = st.poisson.ppf(0.05, self.scenario_tau[i])
        print "expected mean inter frame times: ", self.scenario_tau
        print "send windows: ", self.scenario_send_window
        
        self.max_confidence = 3
        self.confidence = 0
        
        self.scenario = 10
        self.chan_occupied = [False] * self.nchan  # list of true/false values
        self.tau = None
        
        self.message_port_register_out(pmt.intern("scenario"))
        
    def get_scenario(self):
        return self.scenario
        
    def get_chan_occupied(self):
            return [i for i in range(self.nchan) if self.chan_occupied[i]]
        
    def get_tau(self):
        return self.tau
        
    def run_decision_tree(self, inter_frame_times, inter_frame_time_variance):
        chan_occupied = list(inter_frame_times &gt;= 0)  # all channels that have an inter frame arrival time &gt; 0 are regarded as being occupied FIXME: handle wildly different values as being false (e.g., due to one channel no longer being used)
        nchan_occupied = sum(chan_occupied)  # number of occupied channels
        self.tau = np.mean([inter_frame_times[i] for i in range(self.nchan) if chan_occupied[i]])  # inter arrival time averaged over occupied channels
        delta_tau = abs(self.tau - self.scenario_tau)
        
        if nchan_occupied == 1:  # possible scenarios: 0 or 1 (deterministic transmission with tau1 or tau2 on a single channel, respectively)
            possible_scenarios = [0, 1]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            s = possible_scenarios[idx]
        elif nchan_occupied == 2:  # possible scenarios: 2 or 4 (hopping or deterministic with tau1 on two channels, respectively)
            possible_scenarios = [2, 4]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            s = possible_scenarios[idx]
        elif nchan_occupied == 4:  # possible scenarios: 6 (all channels deterministic with tconst), 5 (all channels deterministic with tau1), 3 (all channels hopping with tau1), 7-9 (all channels, Poisson process with different lambdas)
            possible_scenarios = [3, 5, 6, 7, 8, 9]
            idx = np.argmin([delta_tau[i] for i in possible_scenarios])
            if possible_scenarios[idx] == 5 or possible_scenarios[idx] == 9:  # they have the same mean interarrival time, decide based on the variance
              if inter_frame_time_variance &gt; float(self.scenario_tau[9])/2:  # considerable variance indicates the non-deterministic Poisson scenario (expected variance is equal to the mean interframe time)
                s = 9
              else:
                s = 5
            else:
              s = possible_scenarios[idx]
        else:  # 0 or 3 occupied channels is not a valid scenario
            s = 10  # stick with the last estimation
            
        return s, chan_occupied
        
    def post_message(self):
        msg_dict = pmt.make_dict()
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_number"), pmt.from_long(long(self.scenario)))
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_channels"), pmt.to_pmt([bool(c) for c in self.chan_occupied]))
        msg_dict = pmt.dict_add(msg_dict, pmt.intern("scenario_tau"), pmt.from_long(long(self.scenario_send_window[self.scenario])))
        self.message_port_pub(pmt.intern("scenario"), msg_dict)

    def work(self, input_items, output_items):
	scn = output_items[0]
        inter_frame_times = np.array([input_items[i][0] for i in range(self.nchan)])  # current inter frame arrival time per channel
        packet_rate = input_items[4][0]  # not used at the moment
        inter_frame_time_variance = input_items[5][0]  # variance of the inter frame arrival time (averaged over all channels)
        detected_scenario, chan_occupied = self.run_decision_tree(inter_frame_times, inter_frame_time_variance)
	scn[:] = (np.arange(10) == detected_scenario).astype(float)
        if detected_scenario != self.scenario or chan_occupied != self.chan_occupied:
            self.confidence -= 1
            if self.confidence &lt; 0:
                self.scenario = detected_scenario
		
                self.chan_occupied = chan_occupied
                self.confidence = 0
                self.post_message()
        else:
           self.confidence = min(self.confidence + 1, self.max_confidence)
        return 1
</value></param>
<param><key>lambda1</key><value>20</value></param>
<param><key>lambda2</key><value>10</value></param>
<param><key>lambda3</key><value>5</value></param>
<param><key>tau1</key><value>5</value></param>
<param><key>tau2</key><value>10</value></param>
<param><key>tconst</key><value>2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>waterfall</value></param>
<param><key>label2</key><value>scenario</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(3.195e9+fine_frequency_correction, (3/2)*samp_rate)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>type=b200</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>en_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>en_3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>en_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>en_2</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>classifier_vector_average_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0_0_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_0_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_3</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_dl_class_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_energy_detection_vcf_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>classifier_ml_scn_classification_f_0_0_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>classifier_feature_extraction_f_0</source_block_id><sink_block_id>scenario_classification_f</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_frame_detection_f_0</source_block_id><sink_block_id>classifier_feature_extraction_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_ml_scn_classification_f_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_vector_average_vcvc_0</source_block_id><sink_block_id>classifier_dl_class_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_vector_average_vcvc_0</source_block_id><sink_block_id>classifier_dl_class_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>classifier_vector_average_vcvc_0</source_block_id><sink_block_id>classifier_dl_class_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>classifier_energy_detection_vcf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scenario_classification_f</source_block_id><sink_block_id>blocks_vector_to_stream_0_2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scenario_classification_f</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>scenario</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>classifier_frame_detection_f_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
